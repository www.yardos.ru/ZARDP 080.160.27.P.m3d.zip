# KOMPAS-3D part (ZARDP 080.160.27.P.m3d)

Model tree:
1. Операция без истории:1

Texts:
  ЗАРДП 080.160.27-ХХ.Р
  Кран шаровой фланцевый
  ООО "ИК Энерпред-Ярдос"